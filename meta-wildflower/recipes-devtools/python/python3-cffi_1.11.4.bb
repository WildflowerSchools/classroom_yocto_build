require ../../../meta-openembedded/meta-python/recipes-devtools/python/python-cffi.inc

SRC_URI[md5sum] = "8ef0f852498908b20bc508799901fe93"
SRC_URI[sha256sum] = "df9083a992b17a28cd4251a3f5c879e0198bb26c9e808c4647e0a18739f1d11d"

inherit pypi setuptools3
