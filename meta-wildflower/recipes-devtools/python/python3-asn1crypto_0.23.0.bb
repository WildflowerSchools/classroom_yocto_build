inherit setuptools3
require ../../../meta-openembedded/meta-python/recipes-devtools/python/python-asn1crypto.inc
