CACHED_CONFIGUREVARS_append = "ac_cv_working_tzset=yes"
